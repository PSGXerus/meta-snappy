SUMMARY = "Codespell"
HOMEPAGE = "https://github.com/lucasdemarchi/codespell/"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://README.rst;beginline=117;endline=145;md5=6e57de02a5253cfeb417d93d58f09959"

SRC_URI[md5sum] = "9bbdeef5e5d293d8254717f598785f31"
SRC_URI[sha256sum] = "259ad215acc3b3406d65490224d70c6c85068b0b14d997728ed5b1d2ef275b6e"

inherit setuptools3 pypi native

