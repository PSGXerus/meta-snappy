SUMMARY = "WSGI request and response object"
HOMEPAGE = "http://webob.org/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://docs/license.txt;md5=8ed3584bcc78c16da363747ccabc5af5"

SRC_URI[md5sum] = "82d0128e83dd2b712f7fe4bec006ddd5"
SRC_URI[sha256sum] = "fa192842af2a04be36e3c4b4fc85e48fbaada5c462443b20dc3327d33d76ffe8"

PYPI_PACKAGE = "WebOb"

inherit setuptools3 pypi native

