SUMMARY = "A module provides basic functions for parsing mime-type names and matching them against a list of media-ranges."
HOMEPAGE = "https://github.com/dbtsai/python-mimeparse"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=838c366f69b72c5df05c96dff79b35f2"

SRC_URI[md5sum] = "a32ae1df93be1ddb581d1c0fa124bab4"
SRC_URI[sha256sum] = "76e4b03d700a641fd7761d3cd4fdbbdcd787eade1ebfac43f877016328334f78"

inherit setuptools3 pypi native


