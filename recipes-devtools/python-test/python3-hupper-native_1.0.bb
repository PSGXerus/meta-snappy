SUMMARY = "Integrated process monitor for developing and reloading daemons."
HOMEPAGE = "https://github.com/Pylons/hupper"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=2fc91495963af6389c06667be08ccc5c"

SRC_URI[md5sum] = "26e77da7d5ac5858f59af050d1a6eb5a"
SRC_URI[sha256sum] = "afb9584fc387c962824627bb243d7d92c276df608a771b17c8b727a7de34920a"

inherit setuptools3 pypi native


