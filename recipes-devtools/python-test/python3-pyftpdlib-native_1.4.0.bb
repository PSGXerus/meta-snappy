SUMMARY = "Very fast asynchronous FTP server library"
HOMEPAGE = "https://github.com/giampaolo/pyftpdlib/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=05f70340c001186bec994c0b15265d8d"

SRC_URI[md5sum] = "5aeda8287f4e5ba263e48a79f2a246fd"
SRC_URI[sha256sum] = "5fdd1492efe478f4c354f7d65d9308359751c8fb1d0376466b74a76721c5fcf3"

inherit setuptools3 pypi native

