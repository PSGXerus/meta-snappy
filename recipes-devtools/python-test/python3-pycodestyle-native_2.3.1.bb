SUMMARY = "Python style guide checker"
HOMEPAGE = "https://pycodestyle.readthedocs.io/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://pycodestyle.py;beginline=8;endline=26;md5=52ebfe5d2057e1021dfd6558fe7cbd9a"

SRC_URI[md5sum] = "240e342756af30cae0983b16303a2055"
SRC_URI[sha256sum] = "682256a5b318149ca0d2a9185d365d8864a768a28db66a84a2ea946bcc426766"

inherit setuptools3 pypi native

