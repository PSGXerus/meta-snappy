SUMMARY = "The new features in unittest backported to Python 2.4+."
HOMEPAGE = "http://pypi.python.org/pypi/unittest2"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://setup.py;beginline=7;endline=8;md5=2da8867c9906ea349955070ab2015b3a"

SRC_URI[md5sum] = "f72dae5d44f091df36b6b513305ea000"
SRC_URI[sha256sum] = "22882a0e418c284e1f718a822b3b022944d53d2d908e1690b319a9d3eb2c0579"

inherit setuptools3 pypi native


