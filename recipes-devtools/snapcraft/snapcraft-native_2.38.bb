require snapcraft.inc
