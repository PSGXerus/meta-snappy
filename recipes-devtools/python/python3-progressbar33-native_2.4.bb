SUMMARY = "Text progress bar library for Python."
HOMEPAGE = "http://github.com/germangh/python-progressbar"

LICENSE = "LGPL-2.1 & BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6d38698d6f983adff50eb75d8cb26e6b"

SRC_URI[md5sum] = "94c114ea62aaae93489848f5bdb0bbe7"
SRC_URI[sha256sum] = "51fe0d9b3b4023db2f983eeccdfc8c9846b84db8443b9bee002c7f58f4376eff"

inherit setuptools3 pypi native


