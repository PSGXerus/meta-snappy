SUMMARY = "Python interface to libarchive"
HOMEPAGE = "https://github.com/Changaco/python-libarchive-c"

LICENSE = "CC0-1.0"
LIC_FILES_CHKSUM = "file://README.rst;beginline=56;endline=59;md5=6eb922dae7cb03b99ef214e4ae8d1f3f"

SRC_URI[md5sum] = "6c23d0e2cc235a58bc5181f70f880375"
SRC_URI[sha256sum] = "56eadbc383c27ec9cf6aad3ead72265e70f80fa474b20944328db38bab762b04"

inherit setuptools3 pypi native


