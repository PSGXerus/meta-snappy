SUMMARY = "PyXDG contains implementations of freedesktop.org standards in python."
HOMEPAGE = "http://freedesktop.org/wiki/Software/pyxdg"

LICENSE = "LGPL-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=f30a9716ef3762e3467a2f62bf790f0a"

SRC_URI[md5sum] = "bedcdb3a0ed85986d40044c87f23477c"
SRC_URI[sha256sum] = "81e883e0b9517d624e8b0499eb267b82a815c0b7146d5269f364988ae031279d"

inherit setuptools3 pypi native
