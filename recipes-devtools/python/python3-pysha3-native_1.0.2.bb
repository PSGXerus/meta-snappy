SUMMARY = "SHA-3 (Keccak) for Python 2.7 - 3.5"
HOMEPAGE = "https://github.com/tiran/pysha3"

LICENSE = "PSF"
LIC_FILES_CHKSUM = "file://LICENSE;md5=056fea6a4b395a24d0d278bf5c80249e"

SRC_URI[md5sum] = "59cd2db7a9988c1f3f6aee40145e0c96"
SRC_URI[sha256sum] = "fe988e73f2ce6d947220624f04d467faf05f1bbdbc64b0a201296bb3af92739e"

inherit setuptools3 pypi native

