DEPENDS_class-native += "	python3-urllib3-native (>=1.21.1,<1.23) \
				python3-idna-native (>=2.5,<2.7) \
				python3-chardet-native (>=3.0.2,<3.1.0) \
				python3-certifi-native (>=2017.4.17) \
"
