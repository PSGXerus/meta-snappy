SUMMARY = "Friendlier RFC 6265-compliant cookie parser/renderer"
HOMEPAGE = "https://github.com/sashahart/cookies"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://cookies.py;beginline=5;endline=21;md5=995598bc9de2b4c987c2cb87fc24f341"

SRC_URI[md5sum] = "6f4c53aba3ed03e4e7b50812c2c2579a"
SRC_URI[sha256sum] = "d6b698788cae4cfa4e62ef8643a9ca332b79bd96cb314294b864ae8d7eb3ee8e"

inherit setuptools3 pypi native


