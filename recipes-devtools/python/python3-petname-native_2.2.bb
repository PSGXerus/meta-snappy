SUMMARY = "Generate human-readable, random object names"
HOMEPAGE = "https://launchpad.net/petname"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://petname/__main__.py;beginline=7;endline=17;md5=a30e69ae36d8810ba1ded90713c271c5"

SRC_URI[md5sum] = "92a13535d1df0c8d845111347a854941"
SRC_URI[sha256sum] = "be1da50a6aa01e39840e9a4b79b527a333b256733cb681f52669c08df7819ace"

inherit setuptools3 pypi native


